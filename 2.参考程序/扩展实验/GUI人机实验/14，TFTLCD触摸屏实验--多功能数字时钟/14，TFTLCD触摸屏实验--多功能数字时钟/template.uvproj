# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP\ds18b20;.\APP\tftlcd;.\APP\touch;.\GUI;.\Public;.\User;.\APP\adc;.\APP\ds1302;.\APP\time
  group User
    ./User/: main.c
  group Public
    ./Public/: public.c uart.c
  group APP
    ./APP/tftlcd/: tftlcd.c
    ./APP/touch/: touch.c
    ./APP/time/: time.c
  group GUI
    ./GUI/: gui.c
